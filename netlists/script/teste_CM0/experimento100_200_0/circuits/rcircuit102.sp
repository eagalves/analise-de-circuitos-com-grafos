R1 (net1 net2) R=3.9E0
C2 (net2 net1) C=5.6E-14
C3 (net2 net1) C=2.8E-7
R4 (net1 0) R=4.4E1
T5 (0 net1 net1 0) pfet L=9.04E-6 W=9.29E-6
T6 (net2 net2 net2 0) pfet L=0.12E-6 W=4.25E-6
C7 (net2 0) C=3.6E-12
C8 (net1 net2) C=1.5E-5
R9 (net1 net2) R=9.4E6
R10 (net2 net1) R=9.2E3
T11 (net2 net2 net2 0) pfet L=2.85E-6 W=9.72E-6
