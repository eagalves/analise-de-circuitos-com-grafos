T1 (net3 net4 net4 0) nfet L=5.02E-6 W=8.87E-6
T2 (net2 net5 net5 0) pfet L=0.72E-6 W=0.34E-6
C3 (net5 net4) C=6.4E-11
T4 (net2 net3 net3 0) pfet L=3.04E-6 W=4.51E-6
C5 (net4 net1) C=5.1E-14
R6 (net3 0) R=7.0E5
R7 (net4 net2) R=2.4E4
C8 (net1 net4) C=8.4E-8
C9 (net4 net2) C=4.2E-12
R10 (net4 net3) R=3.0E1
R11 (vdd! net4) R=5.7E0
T12 (net5 net1 net1 0) nfet L=4.39E-6 W=9.35E-6
R13 (net1 net3) R=2.8E0
