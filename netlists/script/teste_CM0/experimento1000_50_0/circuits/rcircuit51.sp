T1 (net2 net7 net7 0) nfet L=4.89E-6 W=5.76E-6
R2 (net1 net6) R=1.9E6
C3 (net6 net7) C=0.4E-10
T4 (net2 vdd! vdd! 0) nfet L=0.98E-6 W=8.73E-6
R5 (net8 net6) R=3.0E4
C6 (0 net8) C=3.6E-13
R7 (net4 net6) R=9.3E3
C8 (net5 net6) C=4.2E-7
C9 (0 net10) C=7.7E-8
R10 (net8 net2) R=0.6E2
R11 (net10 net2) R=3.2E2
C12 (0 net2) C=3.6E-13
C13 (net5 net1) C=4.4E-11
C14 (vdd! net5) C=1.8E-9
T15 (net7 net10 net10 0) nfet L=9.35E-6 W=7.28E-6
